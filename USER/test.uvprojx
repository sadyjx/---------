# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103ZE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\ENC28J60;..\uip2.5\uip;..\uIP-APP;..\uip2.5\lib;..\uip2.5\doc;..\uip2.5\unix;..\uip2.5\apps\telnetd;..\uip2.5\apps\dhcpc;..\uip2.5\apps\resolv;..\uip2.5\apps\webclient;..\STM32F10x_FWLib\inc;..\HARDWARE\STMFLASH;..\HARDWARE\WIFI;..\HARDWARE\USART2;..\HARDWARE\TY_SDK;..\HARDWARE\RS485
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LCD/: lcd.c font.c
  group TY-SDK
    ../HARDWARE/TY_SDK/: mcu_api.c protocol.c system.c
software components: CMSIS:CORE 5.4.0
